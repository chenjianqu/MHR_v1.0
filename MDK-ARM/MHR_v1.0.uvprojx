# Keil uVision project MHR_v1.0.uvprojx, settings and files
target MHR_v1.0 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: MHR_v1.0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;        ../Drivers/STM32F4xx_HAL_Driver/Inc;        ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;        ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;        ../Drivers/CMSIS/Include;        ..\System;        ..\Models;        ..\Models\MPU6050;        ..\Models\MPU6050\eMPL;        ..\User;        ..\Models\TFTLCD;        ..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../User/: key.c motor.c pid.c tracksensor.c main_func.c test.c car.c run.c handle.c task.c CoordinateSystem.c
    ../Src/: main.c gpio.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Models
    ../Models/MPU6050/: mpu6050.c
    ../Models/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group System
    ../System/: delay.c myiic.c myuart.c
  group TFTLD
    ../Models/TFTLCD/: Driver.c LcdLib.c lcd.c
  group Head
    ../User/: c.h CoordinateSystem.h key.h led.h motor.h pid.h tracksensor.h
    ../System/: delay.h myiic.h myuart.h sys.h
    ../Inc/: gpio.h main.h stm32f4xx_hal_conf.h stm32f4xx_it.h tim.h usart.h
software components: CMSIS:CORE 4.3.0
